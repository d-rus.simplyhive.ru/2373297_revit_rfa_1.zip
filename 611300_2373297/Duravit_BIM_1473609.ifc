Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: slim_sensowash_slim_shower_toilet_seat_611300.ifc
Time: 2017-11-22T11:17:34
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Slim SensoWash Slim shower toilet seat 611300
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Slim SensoWash Slim shower toilet seat 611300; SKU (BO_prodsku): slim-sensowash-slim-shower-toilet-seat-611300; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): Slim; ProductGroup (BO_prodgroup): SensoWash Slim shower toilet seat; PublishDate (BO_publisdat): 1/11/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 419; Height (BO_height): 17; Depth (BO_depth): 447; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/duravit/product/slim-sensowash-slim-shower-toilet-seat-611300; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/slim-sensowash-slim-shower-toilet-seat-611300; ProductUrl (BO_producturl): http://pro.duravit.com/611300; InstallationInstructions (BO_montins): http://pro.duravit.com/611300; ProductCertification (BO_prodcert): http://pro.duravit.com/611300; TechnicalDescription (BO_techcert): http://pro.duravit.com/611300; BimObjectCategory (BO_bocat): Compound Units; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L721; Uniclass14Description (BO_uniclass_1_4_desc): Sanitary equipment; Uniclass20Code (BO_uniclass_2_0_code): PR-35-12-75; Uniclass20Description (BO_uniclass_2_0_desc): Sanitary Seats; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_06_83; Uniclass2015Description (BO_uniclass2015_desc): Shower seats; NBSReference (BO_nbs_ref): 35-12-75; NBSReferenceDescription (BO_nbs_desc): Sanitary Seats; OmniClassCode (BO_omniclass_code): 23-31 25 11 11; OmniClassDescription (BO_omniclass_name): Toilet Partitions; MasterFormat2014Code (BO_masterformat2014_code): 10 28 13; MasterFormat2014Description (BO_masterformat2014_name): Toilet Accessories; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
